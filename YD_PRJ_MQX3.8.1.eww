<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR\YA_PRJ_MQX3.8.1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


