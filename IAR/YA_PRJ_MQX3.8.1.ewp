# IAR project YA_PRJ_MQX3.8.1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\lib\twrk60n512.iar\; ..\lib\twrk60n512.iar\bsp; ..\lib\twrk60n512.iar\psp; ..\lib\twrk60n512.iar\bsp\Generated_Code; ..\lib\twrk60n512.iar\rtcs; ..\lib\twrk60n512.iar\mfs; ..\lib\twrk60n512.iar\usb\host; ..\lib\twrk60n512.iar\shell; ..\lib\twrk60n512.iar\usb; ..; ..\Source\APP; ..\Source\MQX
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: YA_PRJ_MQX3.8.1.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\lib\twrk60n512.iar\bsp\intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group MFS_Libraries
    ../lib/twrk60n512.iar/mfs/: mfs_twrk60n512_d.a
  group MQX_Libraries
    ../lib/twrk60n512.iar/bsp/: 3.8.1bsp_twrk60n512_130512.a bsp_twrk60n512.a
    ../lib/twrk60n512.iar/psp/: psp_twrk60n512.a psp_twrk60n512_d.a
  group RTCS_Libraries
    ../lib/twrk60n512.iar/rtcs/: rtcs_twrk60n512_d.a
  group Shell_Libraries
    ../lib/twrk60n512.iar/shell/: 3.8.1shell_twrk60n512_130512.a 3.8.1shell_twrk60n512_130513.a shell_twrk60n512.a
  group Source/APP
    ../Source/APP/: DataConvert.c DisTime.c DSPSPI.c LCDDriver.c LCDUart.c MenuView.c pin2.c System.C yada_prj.c
  group Source/MQX
    ../Source/MQX/: FTP_Task.c mem_flash.c mem_ram.c SD_task.c Shell_Task.c tcpip_socket_task.c USB_File.c USB_Task.c
  group USB_Libraries
    ../lib/twrk60n512.iar/usb/host/: usb_classes.c usb_hdk_twrk60n512_d.a
